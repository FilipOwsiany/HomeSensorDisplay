SUMMARY = "SSH server group"
LICENSE = "CLOSED"
inherit packagegroup

RDEPENDS:${PN} = "dropbear"

