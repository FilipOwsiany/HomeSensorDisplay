SUMMARY = "Support package group"
LICENSE = "CLOSED"
inherit packagegroup

RDEPENDS:${PN} += " htop"

